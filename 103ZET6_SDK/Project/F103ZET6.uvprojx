# Keil uVision project F103ZET6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103ZET6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\User\project_config;..\User\bsp_drive\bsp_led;..\User\bsp_drive\bsp_beep;..\User\bsp_drive\bsp_key;..\User\bsp_drive\bsp_SysTick;..\User\bsp_drive\bsp_exti;..\User\bsp_drive\bsp_usart;..\User\user\log;..\User\bsp_drive\bsp_wwdg;..\User\bsp_drive\bsp_time
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group cmsis
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group fwlb
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../User/: main.c stm32f10x_it.c
  group bsp_drive
    ../User/bsp_drive/bsp_led/: bsp_led.c
    ../User/bsp_drive/bsp_beep/: bsp_beep.c
    ../User/bsp_drive/bsp_key/: bsp_key.c
    ../User/bsp_drive/bsp_SysTick/: bsp_SysTick.c
    ../User/bsp_drive/bsp_exti/: bsp_exti.c
    ../User/bsp_drive/bsp_usart/: bsp_usart.c
    ../User/bsp_drive/bsp_wwdg/: bsp_wwdg.c
    ../User/bsp_drive/bsp_time/: bsp_time.c
  group user_module
    ../User/user/log/: log.c
  group doc
    ../Doc/: readme.txt
